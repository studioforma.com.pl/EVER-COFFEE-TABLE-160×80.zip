Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Ever - Coffee table 160x80 H35 - ifc4.ifc
Time: 2023-10-05T11:04:42
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (3)
Name
 | Ever - Coffee table 160x80 H35 - _0 - ObjectType: SketchupGroup
 | Ever - Coffee table 160x80 H35 - _1 - ObjectType: SketchupGroup
 | Ever - Coffee table 160x80 H35 - _2 - ObjectType: SketchupGroup
